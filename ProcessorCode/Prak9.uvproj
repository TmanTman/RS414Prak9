# Keil uVision project Prak9.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LM3S1110 Texas Instruments
  cpu: IRAM(0x20000000-0x20003FFF) IROM(0-0xFFFF) CLOCK(6000000) CPUTYPE("Cortex-M3")
  output: Prak9
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group Startup code
    ./: Startup.s
  group Source Code
    ./: main.c
